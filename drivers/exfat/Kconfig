## drivers/exfat/Kconfig
```kconfig
menuconfig EXFAT
	tristate "Samsung EXFAT support"
	default m
	help
	  Say Y to enable Samsung EXFAT support.
```
